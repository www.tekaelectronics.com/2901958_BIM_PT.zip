Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Versão 1.0
Time: 2022-10-25T16:39:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 25 16:39:38 2022 * Host: LAPTOP-G6NCF4J6 * Database: C:\Users\ASUS\AppData\Local\Temp\5ced871b-cf7f-40fd-84d1-7a318398563a\bd241934-2d8d-4c37-971b-94af6d01d2cc\ifc * Database version: 5507 * Database creation date: Tue Oct 25 16:39:37 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 25 16:39:37 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 25 16:39:37 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Versão 1.0
LongName: BIM Elements; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcElectricDistributionPoint: TEKA_2901958_Wall_Rack_19p_15U_600x450x770_PT:TEKA_2901958_Wall_Rack_19p_15U_600x450x770_PT, 41
In: Level 1
Material: RAL 9018, Plastico RAL 9006, Inox, Aço Laminado a Frio SPCC, Vidro temperado de 5mm
Pset_DistributionFlowElementCommon - Reference: TEKA_2901958_Wall_Rack_19p_15U_600x450x770_PT; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: TEKA
Pset_ProductRequirements - Category: Electrical Equipment
01 GERAL - 01.01 Fabricante: Teka; 01.02 Modelo: 2901958; 01.03 Gama: Bastidor; 01.04 Familia: Bastidor Mural; 01.05 Produto: Bastidor 19", 15U; 01.06 Descricao: Bastidor Mural 19" - 15U (600x450x770); 01.07 Mark_ID: VI 1; 01.08 Autor: ACADBIM
02 MATERIAIS - 02.01 Cor_Caixa: Preto (RAL 9005); 02.02 Material_Caixa: Aço Laminado a Frio SPCC; 02.03 Material_Porta_Frontal: Vidro temperado de 5mm; 02.04 Tratamento_Superficie: Fosfatação e lacagem com epoxy-polyester texturado
03 TECNICAS - 03.01 Dimensoes: 600 x 450 x 770; 03.02 Carga_Maxima [Kg]: 15; 03.03 Unidades_Rack [Un]: 15; 03.04 Original Family Name: TEKA_2901958_Wall_Rack_19p_15U_600x450x770_PT: TEKA_2901958_Wall_Rack_19p_15U_600x450x770_PT
